require u-boot-ti.inc

SRC_URI += "file://0001-Revert-gpio-omap_gpio-Add-DM_FLAG_PRE_RELOC-flag.patch"

PR = "r15"

BRANCH = "ti-u-boot-2018.01"

SRCREV = "efdd6cd5ab525bf1dce5376f9e66c78a38e6e7b0"
